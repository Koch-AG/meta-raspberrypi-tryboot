CMDLINE_ROOT_PARTITION = "XXX"

